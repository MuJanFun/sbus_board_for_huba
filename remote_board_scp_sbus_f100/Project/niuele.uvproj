# Keil uVision project niuele.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: flowmeter +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\fatfs;..\FWlib\inc;..\user;..\user;..\user\pic_codec;..\IICLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/: stm32f10x_it.c main.c delay.c include.h USART.c sbus.c
  group FWLib
    ../FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Start_up
    ../startup/: startup_stm32f10x_md.s
  group CMSIS
    ../user/: core_cm3.c system_stm32f10x.c
  group BSP
    ../user/: BSP.c
